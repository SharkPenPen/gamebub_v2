# Repository SharkPenPen/gamebub_v2 (continued)

## KiCad design pcb/handheld_rev2/handheld.kicad_pcb (continued)

Schematic: ram.kicad_sch

Parts:
C1401, C1402, C1403, C1404, C1405, C1406, C1407, C1410, C1411: 100n; C_0402_1005Metric; LCSC C1525
C1408, C1409: 10u; C_0402_1005Metric; LCSC C15525
U1401: W9825G6KH-6; TSOP-II-54_22.2x10.16mm_P0.8mm; LCSC C62246
U1402: IS61WV25616BLL-10TLI; TSOP-II-44_10.16x18.41mm_P0.8mm; LCSC C53825

Connections:
+3V3_FPGA: C1401.2, C1402.2, C1403.2, C1404.2, C1405.2, C1406.2, C1407.2, C1408.1, C1409.1, C1410.2, C1411.2, U1401.1 (VDD), U1401.3 (VDDQ), U1401.9 (VDDQ), U1401.14 (VDD), U1401.27 (VDD), U1401.43 (VDDQ), U1401.49 (VDDQ), U1402.11 (VDD), U1402.33 (VDD); also elsewhere on the board
GND: C1401.1, C1402.1, C1403.1, C1404.1, C1405.1, C1406.1, C1407.1, C1408.2, C1409.2, C1410.1, C1411.1, U1401.6 (VSSQ), U1401.12 (VSSQ), U1401.28 (VSS), U1401.41 (VSS), U1401.46 (VSSQ), U1401.52 (VSSQ), U1401.54 (VSS), U1402.12 (GND), U1402.34 (GND); also elsewhere on the board
SDRAM_0_~CS: U1401.19 (~CS); also elsewhere on the board
SDRAM_A0: U1401.23 (A0); also elsewhere on the board
SDRAM_A1: U1401.24 (A1); also elsewhere on the board
SDRAM_A2: U1401.25 (A2); also elsewhere on the board
SDRAM_A3: U1401.26 (A3); also elsewhere on the board
SDRAM_A4: U1401.29 (A4); also elsewhere on the board
SDRAM_A5: U1401.30 (A5); also elsewhere on the board
SDRAM_A6: U1401.31 (A6); also elsewhere on the board
SDRAM_A7: U1401.32 (A7); also elsewhere on the board
SDRAM_A8: U1401.33 (A8); also elsewhere on the board
SDRAM_A9: U1401.34 (A9); also elsewhere on the board
SDRAM_A10: U1401.22 (A10/AP); also elsewhere on the board
SDRAM_A11: U1401.35 (A11); also elsewhere on the board
SDRAM_A12: U1401.36 (A12); also elsewhere on the board
SDRAM_BS0: U1401.20 (BS0); also elsewhere on the board
SDRAM_BS1: U1401.21 (BS1); also elsewhere on the board
SDRAM_CKE: U1401.37 (CKE); also elsewhere on the board
SDRAM_CLK: U1401.38 (CLK); also elsewhere on the board
SDRAM_DQ0: U1401.2 (DQ0); also elsewhere on the board
SDRAM_DQ1: U1401.4 (DQ1); also elsewhere on the board
SDRAM_DQ2: U1401.5 (DQ2); also elsewhere on the board
SDRAM_DQ3: U1401.7 (DQ3); also elsewhere on the board
SDRAM_DQ4: U1401.8 (DQ4); also elsewhere on the board
SDRAM_DQ5: U1401.10 (DQ5); also elsewhere on the board
SDRAM_DQ6: U1401.11 (DQ6); also elsewhere on the board
SDRAM_DQ7: U1401.13 (DQ7); also elsewhere on the board
SDRAM_DQ8: U1401.42 (DQ8); also elsewhere on the board
SDRAM_DQ9: U1401.44 (DQ9); also elsewhere on the board
SDRAM_DQ10: U1401.45 (DQ10); also elsewhere on the board
SDRAM_DQ11: U1401.47 (DQ11); also elsewhere on the board
SDRAM_DQ12: U1401.48 (DQ12); also elsewhere on the board
SDRAM_DQ13: U1401.50 (DQ13); also elsewhere on the board
SDRAM_DQ14: U1401.51 (DQ14); also elsewhere on the board
SDRAM_DQ15: U1401.53 (DQ15); also elsewhere on the board
SDRAM_LDQM: U1401.15 (LDQM); also elsewhere on the board
SDRAM_UDQM: U1401.39 (UDQM); also elsewhere on the board
SDRAM_~CAS: U1401.17 (~CAS); also elsewhere on the board
SDRAM_~RAS: U1401.18 (~RAS); also elsewhere on the board
SDRAM_~WE: U1401.16 (~WE); also elsewhere on the board
SRAM_A0: U1402.1 (A0); also elsewhere on the board
SRAM_A1: U1402.2 (A1); also elsewhere on the board
SRAM_A2: U1402.3 (A2); also elsewhere on the board
SRAM_A3: U1402.4 (A3); also elsewhere on the board
SRAM_A4: U1402.5 (A4); also elsewhere on the board
SRAM_A5: U1402.18 (A5); also elsewhere on the board
SRAM_A6: U1402.19 (A6); also elsewhere on the board
SRAM_A7: U1402.20 (A7); also elsewhere on the board
SRAM_A8: U1402.21 (A8); also elsewhere on the board
SRAM_A9: U1402.22 (A9); also elsewhere on the board
SRAM_A10: U1402.23 (A10); also elsewhere on the board
SRAM_A11: U1402.24 (A11); also elsewhere on the board
SRAM_A12: U1402.25 (A12); also elsewhere on the board
SRAM_A13: U1402.26 (A13); also elsewhere on the board
SRAM_A14: U1402.27 (A14); also elsewhere on the board
SRAM_A15: U1402.42 (A15); also elsewhere on the board
SRAM_A16: U1402.43 (A16); also elsewhere on the board
SRAM_A17: U1402.44 (A17); also elsewhere on the board
SRAM_IO0: U1402.7 (IO0); also elsewhere on the board
SRAM_IO1: U1402.8 (IO1); also elsewhere on the board
SRAM_IO2: U1402.9 (IO2); also elsewhere on the board
SRAM_IO3: U1402.10 (IO3); also elsewhere on the board
SRAM_IO4: U1402.13 (IO4); also elsewhere on the board
SRAM_IO5: U1402.14 (IO5); also elsewhere on the board
SRAM_IO6: U1402.15 (IO6); also elsewhere on the board
SRAM_IO7: U1402.16 (IO7); also elsewhere on the board
SRAM_IO8: U1402.29 (IO8); also elsewhere on the board
SRAM_IO9: U1402.30 (IO9); also elsewhere on the board
SRAM_IO10: U1402.31 (IO10); also elsewhere on the board
SRAM_IO11: U1402.32 (IO11); also elsewhere on the board
SRAM_IO12: U1402.35 (IO12); also elsewhere on the board
SRAM_IO13: U1402.36 (IO13); also elsewhere on the board
SRAM_IO14: U1402.37 (IO14); also elsewhere on the board
SRAM_IO15: U1402.38 (IO15); also elsewhere on the board
SRAM_~CE: U1402.6 (~CE); also elsewhere on the board
SRAM_~LB: U1402.39 (~LB); also elsewhere on the board
SRAM_~OE: U1402.41 (~OE); also elsewhere on the board
SRAM_~UB: U1402.40 (~UB); also elsewhere on the board
SRAM_~WE: U1402.17 (~WE); also elsewhere on the board

Schematic: fpga_io_34.kicad_sch

Parts:
C1101, C1102, C1103, C1104: 470n; C_0402_1005Metric; LCSC C47339
C1105, C1106: 4u7; C_0402_1005Metric; LCSC C23733
U601: XC7A100T-CSG324; Xilinx_CSG324; LCSC C1521791

Connections:
+3V3_FPGA: C1101.1, C1102.1, C1103.1, C1104.1, C1105.1, C1106.1, U601.K4 (VCCO_34), U601.N3 (VCCO_34), U601.P6 (VCCO_34), U601.T2 (VCCO_34), U601.U5 (VCCO_34), U601.V8 (VCCO_34); also elsewhere on the board
BTN_A: U601.N5 (IO_L13P_T2_MRCC_34); also elsewhere on the board
BTN_B: U601.P5 (IO_L13N_T2_MRCC_34); also elsewhere on the board
BTN_R: U601.L5 (IO_L6N_T0_VREF_34); also elsewhere on the board
BTN_Start: U601.K5 (IO_L5P_T0_34); also elsewhere on the board
BTN_X: U601.L6 (IO_L6P_T0_34); also elsewhere on the board
BTN_Y: U601.M6 (IO_L18P_T2_34); also elsewhere on the board
GND: C1101.2, C1102.2, C1103.2, C1104.2, C1105.2, C1106.2; also elsewhere on the board
SDRAM_0_~CS: U601.V1 (IO_L7N_T1_34); also elsewhere on the board
SDRAM_A0: U601.R3 (IO_L11P_T1_SRCC_34); also elsewhere on the board
SDRAM_A1: U601.T3 (IO_L11N_T1_SRCC_34); also elsewhere on the board
SDRAM_A2: U601.T4 (IO_L12N_T1_MRCC_34); also elsewhere on the board
SDRAM_A3: U601.R5 (IO_L19N_T3_VREF_34); also elsewhere on the board
SDRAM_A4: U601.R6 (IO_L19P_T3_34); also elsewhere on the board
SDRAM_A5: U601.T6 (IO_L23N_T3_34); also elsewhere on the board
SDRAM_A6: U601.R7 (IO_L23P_T3_34); also elsewhere on the board
SDRAM_A7: U601.R8 (IO_L24P_T3_34); also elsewhere on the board
SDRAM_A8: U601.T8 (IO_L24N_T3_34); also elsewhere on the board
SDRAM_A9: U601.U2 (IO_L9P_T1_DQS_34); also elsewhere on the board
SDRAM_A10: U601.P4 (IO_L14P_T2_SRCC_34); also elsewhere on the board
SDRAM_A11: U601.V2 (IO_L9N_T1_DQS_34); also elsewhere on the board
SDRAM_A12: U601.U3 (IO_L8N_T1_34); also elsewhere on the board
SDRAM_BS0: U601.N4 (IO_L16N_T2_34); also elsewhere on the board
SDRAM_BS1: U601.P3 (IO_L14N_T2_SRCC_34); also elsewhere on the board
SDRAM_CKE: U601.U4 (IO_L8P_T1_34); also elsewhere on the board
SDRAM_CLK: U601.V4 (IO_L10N_T1_34); also elsewhere on the board
SDRAM_DQ0: U601.P2 (IO_L15P_T2_DQS_34); also elsewhere on the board
SDRAM_DQ1: U601.N2 (IO_L3P_T0_DQS_34); also elsewhere on the board
SDRAM_DQ2: U601.N1 (IO_L3N_T0_DQS_34); also elsewhere on the board
SDRAM_DQ3: U601.M2 (IO_L4N_T0_34); also elsewhere on the board
SDRAM_DQ4: U601.M1 (IO_L1N_T0_34); also elsewhere on the board
SDRAM_DQ5: U601.L1 (IO_L1P_T0_34); also elsewhere on the board
SDRAM_DQ6: U601.M3 (IO_L4P_T0_34); also elsewhere on the board
SDRAM_DQ7: U601.M4 (IO_L16P_T2_34); also elsewhere on the board
SDRAM_DQ8: U601.V5 (IO_L10P_T1_34); also elsewhere on the board
SDRAM_DQ9: U601.U6 (IO_L22N_T3_34); also elsewhere on the board
SDRAM_DQ10: U601.V6 (IO_L20N_T3_34); also elsewhere on the board
SDRAM_DQ11: U601.U7 (IO_L22P_T3_34); also elsewhere on the board
SDRAM_DQ12: U601.V7 (IO_L20P_T3_34); also elsewhere on the board
SDRAM_DQ13: U601.U8 (IO_25_34); also elsewhere on the board
SDRAM_DQ14: U601.U9 (IO_L21P_T3_DQS_34); also elsewhere on the board
SDRAM_DQ15: U601.V9 (IO_L21N_T3_DQS_34); also elsewhere on the board
SDRAM_LDQM: U601.R1 (IO_L17P_T2_34); also elsewhere on the board
SDRAM_UDQM: U601.T5 (IO_L12P_T1_MRCC_34); also elsewhere on the board
SDRAM_~CAS: U601.T1 (IO_L17N_T2_34); also elsewhere on the board
SDRAM_~RAS: U601.U1 (IO_L7P_T1_34); also elsewhere on the board
SDRAM_~WE: U601.R2 (IO_L15N_T2_DQS_34); also elsewhere on the board

Schematic: fpga_power.kicad_sch

Parts:
C601, C602, C603, C604, C619: 100u; C_1206_3216Metric; LCSC C15008
C605, C606, C607, C608, C609, C610, C623, C624: 4u7; C_0402_1005Metric; LCSC C23733
C611, C612, C613, C614, C615, C616, C617, C618, C620, C621, C625, C626, C627, C628: 470n; C_0402_1005Metric; LCSC C47339
C622, C629: 47u; C_0805_2012Metric; LCSC C16780
U601: XC7A100T-CSG324; Xilinx_CSG324; LCSC C1521791

Connections:
+1V0: C601.1, C602.1, C603.1, C604.1, C605.1, C606.1, C607.1, C608.1, C609.1, C610.1, C611.1, C612.1, C613.1, C614.1, C615.1, C616.1, C617.1, C618.1, C619.1, C620.1, C621.1, U601.F8 (VCCINT), U601.F10 (VCCBRAM), U601.G7 (VCCINT), U601.G9 (VCCINT), U601.G11 (VCCBRAM), U601.H8 (VCCINT), U601.J7 (VCCINT), U601.J11 (VCCINT), U601.K8 (VCCINT), U601.L7 (VCCINT), U601.L11 (VCCINT), U601.M8 (VCCINT), U601.M10 (VCCINT), U601.N7 (VCCINT), U601.N9 (VCCINT), U601.N11 (VCCINT); also elsewhere on the board
+1V8: C622.1, C623.1, C624.1, C625.1, C626.1, C627.1, C628.1, U601.F12 (VCCAUX), U601.H10 (VCCADC_0), U601.H12 (VCCAUX), U601.K12 (VCCAUX), U601.M12 (VCCAUX); also elsewhere on the board
+3V3_FPGA: C629.1; also elsewhere on the board
GND: C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C611.2, C612.2, C613.2, C614.2, C615.2, C616.2, C617.2, C618.2, C619.2, C620.2, C621.2, C622.2, C623.2, C624.2, C625.2, C626.2, C627.2, C628.2, C629.2, U601.A2 (GND), U601.A12 (GND), U601.B5 (GND), U601.B15 (GND), U601.C8 (GND), U601.C18 (GND), U601.D1 (GND), U601.D11 (GND), U601.E4 (GND), U601.E8 (VCCBATT_0), U601.E14 (GND), U601.F7 (GND), U601.F9 (GND), U601.F11 (GND), U601.F17 (GND), U601.G8 (GND), U601.G10 (GND), U601.G12 (GND), U601.H3 (GND), U601.H7 (GND), U601.H9 (GNDADC_0), U601.H11 (GND), U601.H13 (GND), U601.J6 (GND), U601.J8 (GND), U601.J12 (GND), U601.J16 (GND), U601.K7 (GND), U601.K11 (GND), U601.L2 (GND), U601.L8 (GND), U601.L12 (GND), U601.M5 (GND), U601.M7 (GND), U601.M9 (GND), U601.M11 (GND), U601.M15 (GND), U601.N8 (GND), U601.N10 (GND), U601.N12 (GND), U601.N18 (GND), U601.P1 (GND), U601.R4 (GND), U601.R14 (GND), U601.T7 (GND), U601.T17 (GND), U601.U10 (GND), U601.V3 (GND), U601.V13 (GND); also elsewhere on the board

Notes on the sheet:
Consider adding ferrite bead to GNDADC
Bulk decoupling capacitor shared between 4x IO banks sharing same VCCO (3.3V)

Schematic: audio.kicad_sch

Parts:
C1701, C1703, C1709, C1711: 10u; C_0402_1005Metric; LCSC C15525
C1702, C1704, C1706, C1708, C1710, C1712: 100n; C_0402_1005Metric; LCSC C1525
C1705, C1707: 22u; C_0805_2012Metric; LCSC C45783
C1713, C1714: 100u; C_1206_3216Metric; LCSC C15008
J1701: SPK_L; Speaker_Same_Sky_CMS-160903-18S-X8
J1702: SPK_R; Speaker_Same_Sky_CMS-160903-18S-X8
J1703: Headphone Jack; Jack_3.5mm_CUI_SJ-43614-SMT
Q1701: AO3400A; SOT-23; LCSC C20917
R1701: 100K; R_0402_1005Metric; LCSC C25741
R1702: 1K; R_0402_1005Metric; LCSC C11702
R1703: 2K2; R_0402_1005Metric; LCSC C25879
R1704: 10K; R_0402_1005Metric; LCSC C25744
U1701: TLV320DAC3101; VQFN-32-1EP_5x5mm_P0.5mm_EP3.5x3.5mm; LCSC C2651664

Connections:
+1V8: C1709.1, C1710.2, U1701.3 (DVDD); also elsewhere on the board
+3V3: C1701.1, C1702.2, C1703.1, C1704.2, C1711.1, C1712.2, U1701.2 (IOVDD), U1701.17 (AVDD), U1701.28 (HPVDD); also elsewhere on the board
/Audio/DAC_INT: R1702.2, R1704.1, U1701.32 (GPIO1)
/Audio/DAC_INT_R: Q1701.1 (G), R1702.1
/Audio/HeadphoneJack_Tip: C1714.2, J1703.T
/Audio/Headphone_Jack_R: C1713.2, J1703.R1
/Audio/Headphone_Left: C1714.1, U1701.27 (HPL)
/Audio/Headphone_Mic: J1703.S, R1703.2, U1701.11 (VOL/MICDET)
/Audio/Headphone_Right: C1713.1, U1701.30 (HPR)
/Audio/MICBIAS: R1703.1, U1701.12 (MICBIAS)
/Audio/Speaker_Left_M: J1701.1, U1701.19 (SPLM)
/Audio/Speaker_Left_P: J1701.2, U1701.22 (SPLP)
/Audio/Speaker_Right_M: J1702.1, U1701.23 (SPRM)
/Audio/Speaker_Right_P: J1702.2, U1701.26 (SPRP)
DAC_BCLK: U1701.7 (BCLK); also elsewhere on the board
DAC_DIN: U1701.5 (DIN); also elsewhere on the board
DAC_MCLK: U1701.8 (MCLK); also elsewhere on the board
DAC_WCLK: U1701.6 (WCLK); also elsewhere on the board
DAC_~RESET: R1701.1, U1701.31 (~RESET); also elsewhere on the board
GND: C1701.2, C1702.1, C1703.2, C1704.1, C1705.2, C1706.1, C1707.2, C1708.1, C1709.2, C1710.1, C1711.2, C1712.1, J1703.R2, Q1701.2 (S), R1701.2, R1704.2, U1701.1 (IOVSS), U1701.16 (AVSS), U1701.18 (DVSS), U1701.20 (SPLVSS), U1701.25 (SPRVSS), U1701.29 (HPVSS), U1701.33 (EP); also elsewhere on the board
I2C0_SCL: U1701.10 (SCL); also elsewhere on the board
I2C0_SDA: U1701.9 (SDA); also elsewhere on the board
MCU_~IRQ: Q1701.3 (D); also elsewhere on the board
VSYS: C1705.1, C1706.2, C1707.1, C1708.2, U1701.21 (SPLVDD), U1701.24 (SPRVDD); also elsewhere on the board

Notes on the sheet:
CTIA (Apple) style Tip is Left R1 is Right R2 is GND Sleeve is Mic
Headphone Jack
nFET converts push-pull active-high DAC interrupt into open-drain active-low MCU_~{INT}
CMS-160903-18S-X8
Speaker
I2C Addr: 0x18

Schematic: fpga_io_14.kicad_sch

Parts:
C801, C802, C803, C804: 470n; C_0402_1005Metric; LCSC C47339
C805, C806: 4u7; C_0402_1005Metric; LCSC C23733
D801: H5VU25U; Diodes_UDFN-10_1.0x2.5mm_P0.5mm; LCSC C7420374
J801: PMOD; PinSocket_1x06_P2.54mm_Horizontal_SMD
R801: 1K; R_0402_1005Metric; LCSC C11702
U601: XC7A100T-CSG324; Xilinx_CSG324; LCSC C1521791

Connections:
+3V3_FPGA: C801.1, C802.1, C803.1, C804.1, C805.1, C806.1, J801.1, R801.2, U601.L17 (VCCO_14), U601.N13 (VCCO_14), U601.P16 (VCCO_14), U601.T12 (VCCO_14), U601.U15 (VCCO_14), U601.V18 (VCCO_14); also elsewhere on the board
/FPGA IO Bank 14/FPGA_PUDC_B: R801.1, U601.L15 (IO_L3P_T0_DQS_PUDC_B_14)
/FPGA IO Bank 14/PMOD_1: D801.5 (K4), D801.6 (K4), J801.6, U601.M14 (IO_L2N_T0_D03_14)
/FPGA IO Bank 14/PMOD_2: D801.4 (K3), D801.7 (K3), J801.5, U601.N14 (IO_L8P_T1_D11_14)
/FPGA IO Bank 14/PMOD_3: D801.2 (K2), D801.9 (K2), J801.4, U601.P14 (IO_L8N_T1_D12_14)
/FPGA IO Bank 14/PMOD_4: D801.1 (K1), D801.10 (K1), J801.3, U601.M13 (IO_L6N_T0_D08_VREF_14)
FPGA_SPI_D0: U601.K18 (IO_L1N_T0_D01_DIN_14); also elsewhere on the board
GB_Cart_VIN: U601.L13 (IO_L6P_T0_FCS_B_14); also elsewhere on the board
GB_Dir_VIN: U601.L14 (IO_L2P_T0_D02_14); also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, C805.2, C806.2, D801.3 (A), D801.8 (A), J801.2; also elsewhere on the board
LCD_DB10: U601.L18 (IO_L4P_T0_D04_14); also elsewhere on the board
LCD_DB11: U601.K17 (IO_L1P_T0_D00_MOSI_14); also elsewhere on the board
LCD_TE: U601.T11 (IO_L19P_T3_A10_D26_14); also elsewhere on the board
SRAM_A0: U601.N17 (IO_L9P_T1_DQS_14); also elsewhere on the board
SRAM_A1: U601.M17 (IO_L10N_T1_D15_14); also elsewhere on the board
SRAM_A2: U601.M18 (IO_L4N_T0_D05_14); also elsewhere on the board
SRAM_A3: U601.T9 (IO_L24P_T3_A01_D17_14); also elsewhere on the board
SRAM_A4: U601.T10 (IO_L24N_T3_A00_D16_14); also elsewhere on the board
SRAM_A5: U601.P15 (IO_L13P_T2_MRCC_14); also elsewhere on the board
SRAM_A6: U601.N16 (IO_L11N_T1_SRCC_14); also elsewhere on the board
SRAM_A7: U601.N15 (IO_L11P_T1_SRCC_14); also elsewhere on the board
SRAM_A8: U601.M16 (IO_L10P_T1_D14_14); also elsewhere on the board
SRAM_A9: U601.L16 (IO_L3N_T0_DQS_EMCCLK_14); also elsewhere on the board
SRAM_A10: U601.V12 (IO_L20N_T3_A07_D23_14); also elsewhere on the board
SRAM_A11: U601.U11 (IO_L19N_T3_A09_D25_VREF_14); also elsewhere on the board
SRAM_A12: U601.V11 (IO_L21N_T3_DQS_A06_D22_14); also elsewhere on the board
SRAM_A13: U601.V10 (IO_L21P_T3_DQS_14); also elsewhere on the board
SRAM_A14: U601.U12 (IO_L20P_T3_A08_D24_14); also elsewhere on the board
SRAM_A15: U601.R18 (IO_L7P_T1_D09_14); also elsewhere on the board
SRAM_A16: U601.P17 (IO_L12P_T1_MRCC_14); also elsewhere on the board
SRAM_A17: U601.P18 (IO_L9N_T1_DQS_D13_14); also elsewhere on the board
SRAM_IO0: U601.R11 (IO_0_14); also elsewhere on the board
SRAM_IO1: U601.R12 (IO_L5P_T0_D06_14); also elsewhere on the board
SRAM_IO2: U601.T13 (IO_L23P_T3_A03_D19_14); also elsewhere on the board
SRAM_IO3: U601.R13 (IO_L5N_T0_D07_14); also elsewhere on the board
SRAM_IO4: U601.T14 (IO_L14P_T2_SRCC_14); also elsewhere on the board
SRAM_IO5: U601.T15 (IO_L14N_T2_SRCC_14); also elsewhere on the board
SRAM_IO6: U601.T16 (IO_L15N_T2_DQS_DOUT_CSO_B_14); also elsewhere on the board
SRAM_IO7: U601.R16 (IO_L15P_T2_DQS_RDWR_B_14); also elsewhere on the board
SRAM_IO8: U601.U13 (IO_L23N_T3_A02_D18_14); also elsewhere on the board
SRAM_IO9: U601.V14 (IO_L22N_T3_A04_D20_14); also elsewhere on the board
SRAM_IO10: U601.U14 (IO_L22P_T3_A05_D21_14); also elsewhere on the board
SRAM_IO11: U601.V15 (IO_L16P_T2_CSI_B_14); also elsewhere on the board
SRAM_IO12: U601.V16 (IO_L16N_T2_A15_D31_14); also elsewhere on the board
SRAM_IO13: U601.U16 (IO_L18P_T2_A12_D28_14); also elsewhere on the board
SRAM_IO14: U601.V17 (IO_L18N_T2_A11_D27_14); also elsewhere on the board
SRAM_IO15: U601.U18 (IO_L17N_T2_A13_D29_14); also elsewhere on the board
SRAM_~CE: U601.R10 (IO_25_14); also elsewhere on the board
SRAM_~LB: U601.U17 (IO_L17P_T2_A14_D30_14); also elsewhere on the board
SRAM_~OE: U601.R17 (IO_L12N_T1_MRCC_14); also elsewhere on the board
SRAM_~UB: U601.T18 (IO_L7N_T1_D10_14); also elsewhere on the board
SRAM_~WE: U601.R15 (IO_L13N_T2_MRCC_14); also elsewhere on the board

Notes on the sheet:
PMOD
PUDC_B high disables pull-ups during boot

Schematic: esp32_s3.kicad_sch

Parts:
C401, C403: 100n; C_0402_1005Metric; LCSC C1525
C402: 22u; C_0805_2012Metric; LCSC C45783
D401: STATUS_LED; LED_0805_2012Metric; LCSC C2297
J401: TP_I2C; PinSocket_1x04_P2.54mm_Vertical; not fitted
J402: Micro_SD_Card_Det1; microSD_G-Switch_GT-TF003-H0185-02; LCSC C5155564
Q401: AO3400A; SOT-23; LCSC C20917
R401, R403, R420, R421, R422, R423, R424, R425, R426, R427: 10K; R_0402_1005Metric; LCSC C25744
R402, R406, R408, R409, R410, R411, R413, R414, R415, R416, R417, R418, R419: 0R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; LCSC C17168
R404, R405: 3K3; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; LCSC C25890
R407: 2K2; R_0402_1005Metric; LCSC C25879
R412: 100K; R_0402_1005Metric; LCSC C25741
TP401, TP402: FPGA_SPI_~{CS}; TestPoint_Pad_D1.0mm
U401: ESP32-S3-MINI-1-N8; ESP32-S3-MINI-1; LCSC C2913206

Connections:
+3V3: C401.2, C402.1, C403.2, J402.4 (VDD), R401.1, R403.1, R404.1, R405.1, R407.1, R412.1, R420.1, R421.1, R422.1, R423.1, R424.1, R425.1, R426.2, U401.3 (3V3); also elsewhere on the board
+3V3_PG: R401.2, U401.45 (EN); also elsewhere on the board
/ESP32-S3/ESP32_RX: TP402.1, U401.40 (U0RXD/GPIO44)
/ESP32-S3/ESP32_SDIO_CLK: R416.2, U401.28 (GPIO33)
/ESP32-S3/ESP32_SDIO_CMD: R418.1, U401.27 (GPIO47)
/ESP32-S3/ESP32_SDIO_D0: R417.2, U401.29 (GPIO34)
/ESP32-S3/ESP32_SDIO_D1: R419.1, U401.30 (GPIO48)
/ESP32-S3/ESP32_SDIO_D2: R415.1, U401.25 (GPIO21)
/ESP32-S3/ESP32_SDIO_D3: R414.2, U401.26 (GPIO26)
/ESP32-S3/ESP32_SPI2_CLK: R410.1, U401.16 (GPIO12)
/ESP32-S3/ESP32_SPI2_D0: R409.1, U401.15 (GPIO11)
/ESP32-S3/ESP32_SPI2_D1: R411.1, U401.17 (GPIO13)
/ESP32-S3/ESP32_SPI2_D2: R413.1, U401.18 (GPIO14)
/ESP32-S3/ESP32_SPI2_D3: R408.1, U401.13 (GPIO9)
/ESP32-S3/ESP32_TX: TP401.1, U401.39 (U0TXD/GPIO43)
/ESP32-S3/ESP32_USB_D+: R402.1, U401.24 (GPIO20/USB_D+)
/ESP32-S3/ESP32_USB_D-: R406.1, U401.23 (GPIO19/USB_D-)
/ESP32-S3/SDIO_CLK: J402.5 (CLK), R416.1, R423.2
/ESP32-S3/SDIO_CMD: J402.3 (CMD), R418.2, R422.2
/ESP32-S3/SDIO_D0: J402.7 (DAT0), R417.1, R424.2
/ESP32-S3/SDIO_D1: J402.8 (DAT1), R419.2, R425.2
/ESP32-S3/SDIO_D2: J402.1 (DAT2), R415.2, R420.2
/ESP32-S3/SDIO_D3/~CS: J402.2 (DAT3/CD), R414.1, R421.2
/ESP32-S3/SD_Detect: R427.2, U401.31 (GPIO35)
/ESP32-S3/SD_Detect_s: J402.9 (DET), R426.1, R427.1
/ESP32-S3/STATUS_LED: Q401.1 (G), R412.2, U401.32 (GPIO36)
/ESP32-S3/Status_LED_A: D401.2 (A), R407.2
/ESP32-S3/Status_LED_K: D401.1 (K), Q401.3 (D)
BATT_CHG: U401.35 (GPIO39/MTCK); also elsewhere on the board
BTN_Home: U401.4 (GPIO0/BOOT); also elsewhere on the board
BTN_VOL_DOWN: U401.36 (GPIO40/MTDO); also elsewhere on the board
BTN_VOL_UP: U401.37 (GPIO41/MTDI); also elsewhere on the board
DAC_~RESET: U401.41 (GPIO45); also elsewhere on the board
FPGA_DONE: U401.10 (GPIO6); also elsewhere on the board
FPGA_INIT_B: U401.12 (GPIO8); also elsewhere on the board
FPGA_POWER_EN: U401.44 (GPIO46); also elsewhere on the board
FPGA_PROGRAM_B: U401.11 (GPIO7); also elsewhere on the board
FPGA_SPI_CLK: R410.2; also elsewhere on the board
FPGA_SPI_D0: R409.2; also elsewhere on the board
FPGA_SPI_D1: R411.2; also elsewhere on the board
FPGA_SPI_D2: R413.2; also elsewhere on the board
FPGA_SPI_D3: R408.2; also elsewhere on the board
FPGA_SPI_~CS: U401.14 (GPIO10); also elsewhere on the board
GND: C401.1, C402.2, C403.1, J401.4, J402.6 (VSS), J402.10 (SHIELD), Q401.2 (S), U401.1 (GND), U401.2 (GND), U401.42 (GND), U401.43 (GND), U401.46 (GND), U401.47 (GND), U401.48 (GND), U401.49 (GND), U401.50 (GND), U401.51 (GND), U401.52 (GND), U401.53 (GND), U401.54 (GND), U401.55 (GND), U401.56 (GND), U401.57 (GND), U401.58 (GND), U401.59 (GND), U401.60 (GND), U401.61 (GND), U401.62 (GND), U401.63 (GND), U401.64 (GND), U401.65 (GND); also elsewhere on the board
I2C0_SCL: J401.2, R404.2, U401.33 (GPIO37); also elsewhere on the board
I2C0_SDA: J401.3, R405.2, U401.34 (GPIO38); also elsewhere on the board
LCD_BACKLIGHT: U401.38 (GPIO42/MTMS); also elsewhere on the board
LCD_D/~CX: U401.7 (GPIO3); also elsewhere on the board
LCD_SPI_CLK: U401.8 (GPIO4); also elsewhere on the board
LCD_SPI_PICO: U401.9 (GPIO5); also elsewhere on the board
LCD_~CS: U401.6 (GPIO2); also elsewhere on the board
LCD_~RST: U401.5 (GPIO1); also elsewhere on the board
MCU_~IRQ: J401.1, R403.2, U401.20 (GPIO16); also elsewhere on the board
USB_D+: R402.2; also elsewhere on the board
USB_D-: R406.2; also elsewhere on the board
~POWER_SW: U401.19 (GPIO15); also elsewhere on the board
~VBUS_PGOOD: U401.21 (GPIO17); also elsewhere on the board

Notes on the sheet:
ESP32-S3 ~{IRQ} is open-drain
Power / Status LED
microSD Slot

Schematic: usb.kicad_sch

Parts:
D501, D502, D503: H5VU25U; Diodes_UDFN-10_1.0x2.5mm_P0.5mm; LCSC C7420374
J501: USB_C_Receptacle_USB2.0; USB-C-SMD_TYPE-C-24P-QT; LCSC C2681555
R501, R502: 5K1; R_0402_1005Metric; LCSC C25905

Connections:
/USB/USB_CC1: J501.A5 (CC1), R501.1
/USB/USB_CC2: J501.B5 (CC2), R502.1
GND: D501.3 (A), D501.8 (A), D502.3 (A), D502.8 (A), D503.3 (A), D503.8 (A), J501.A1 (GND), J501.A12 (GND), J501.B1 (GND), J501.B12 (GND), J501.S1 (SHIELD), R501.2, R502.2; also elsewhere on the board
HDMI_CLK+: D503.4 (K3), D503.7 (K3), J501.A10 (RX2-); also elsewhere on the board
HDMI_CLK-: D503.5 (K4), D503.6 (K4), J501.A11 (RX2+); also elsewhere on the board
HDMI_D0+: D502.2 (K2), D502.9 (K2), J501.B3 (TX2-); also elsewhere on the board
HDMI_D0-: D502.1 (K1), D502.10 (K1), J501.B2 (TX2+); also elsewhere on the board
HDMI_D1+: D503.1 (K1), D503.10 (K1), J501.A2 (TX1+); also elsewhere on the board
HDMI_D1-: D503.2 (K2), D503.9 (K2), J501.A3 (TX1-); also elsewhere on the board
HDMI_D2+: D502.5 (K4), D502.6 (K4), J501.B11 (RX1+); also elsewhere on the board
HDMI_D2-: D502.4 (K3), D502.7 (K3), J501.B10 (RX1-); also elsewhere on the board
USB_D+: D501.2 (K2), D501.9 (K2), J501.A6 (D+), J501.B6 (D+); also elsewhere on the board
USB_D-: D501.4 (K3), D501.7 (K3), J501.A7 (D-), J501.B7 (D-); also elsewhere on the board
USB_SBU1: D501.5 (K4), D501.6 (K4), J501.A8 (SBU1); also elsewhere on the board
USB_SBU2: D501.1 (K1), D501.10 (K1), J501.B8 (SBU2); also elsewhere on the board
VBUS: J501.A4 (VBUS), J501.A9 (VBUS), J501.B4 (VBUS), J501.B9 (VBUS); also elsewhere on the board

Schematic: buttons.kicad_sch

Parts:
C1601: 100n; C_0402_1005Metric; LCSC C1525
R1601, R1602, R1603, R1604, R1605, R1606, R1607, R1608, R1609, R1610, R1611, R1612, R1613, R1614, R1615, R1616, R1617, R1618, R1619, R1620, R1621, R1622, R1623, R1624, R1625, R1626, R1627, R1628, R1629, R1630: 10K; R_0402_1005Metric; LCSC C25744
SW1601: Up; SW_SPST_SKRR; LCSC C97437
SW1602: X; SW_SPST_SKRR; LCSC C97437
SW1603: Left; SW_SPST_SKRR; LCSC C97437
SW1604: Right; SW_SPST_SKRR; LCSC C97437
SW1605: Y; SW_SPST_SKRR; LCSC C97437
SW1606: A; SW_SPST_SKRR; LCSC C97437
SW1607: Down; SW_SPST_SKRR; LCSC C97437
SW1608: B; SW_SPST_SKRR; LCSC C97437
SW1609: Select; SW_SPST_SKRB; LCSC C115356
SW1610: Home; SW_SPST_SKRB; LCSC C115356
SW1611: Start; SW_SPST_SKRB; LCSC C115356
SW1612: L; SW_Tactile_SPST_PTS645Vxx13SMT
SW1613: R; SW_Tactile_SPST_PTS645Vxx13SMT
SW1614: Vol_Up; SW_SPST_SKSC; LCSC C115361
SW1615: Vol_Down; SW_SPST_SKSC; LCSC C115361
U1601: TCA9535PWR; TSSOP-24_4.4x7.8mm_P0.65mm; LCSC C130204

Connections:
+3V3: C1601.1, R1601.1, R1602.1, R1605.1, R1606.1, R1607.1, R1608.1, R1613.1, R1614.1, R1617.1, R1618.1, R1619.1, R1623.1, R1625.1, R1626.1, R1629.1, U1601.24 (VCC); also elsewhere on the board
/Buttons/BTN_A_s: R1608.2, R1612.2, SW1606.1
/Buttons/BTN_B_s: R1614.2, R1616.2, SW1608.1
/Buttons/BTN_Down_s: R1613.2, R1615.2, SW1607.1
/Buttons/BTN_Home_s: R1618.2, R1621.2, SW1610.1
/Buttons/BTN_L_s: R1623.2, R1624.2, SW1612.1
/Buttons/BTN_Left_s: R1605.2, R1609.2, SW1603.1
/Buttons/BTN_R_s: R1625.2, R1627.2, SW1613.1
/Buttons/BTN_Right_s: R1606.2, R1610.2, SW1604.1
/Buttons/BTN_Select_s: R1617.2, R1620.2, SW1609.1
/Buttons/BTN_Start_s: R1619.2, R1622.2, SW1611.1
/Buttons/BTN_Up_s: R1601.2, R1603.2, SW1601.1
/Buttons/BTN_Vol_Down_s: R1629.2, R1630.2, SW1615.1
/Buttons/BTN_Vol_Up_s: R1626.2, R1628.2, SW1614.1
/Buttons/BTN_X_s: R1602.2, R1604.2, SW1602.1
/Buttons/BTN_Y_s: R1607.2, R1611.2, SW1605.1
BTN_A: R1612.1, U1601.7 (P03); also elsewhere on the board
BTN_B: R1616.1, U1601.8 (P04); also elsewhere on the board
BTN_Down: R1615.1, U1601.18 (P15); also elsewhere on the board
BTN_Home: R1621.1; also elsewhere on the board
BTN_L: R1624.1, U1601.14 (P11); also elsewhere on the board
BTN_Left: R1609.1, U1601.17 (P14); also elsewhere on the board
BTN_R: R1627.1, U1601.4 (P00); also elsewhere on the board
BTN_Right: R1610.1, U1601.16 (P13); also elsewhere on the board
BTN_Select: R1620.1, U1601.19 (P16); also elsewhere on the board
BTN_Start: R1622.1, U1601.20 (P17); also elsewhere on the board
BTN_Up: R1603.1, U1601.15 (P12); also elsewhere on the board
BTN_VOL_DOWN: R1630.1; also elsewhere on the board
BTN_VOL_UP: R1628.1; also elsewhere on the board
BTN_X: R1604.1, U1601.5 (P01); also elsewhere on the board
BTN_Y: R1611.1, U1601.6 (P02); also elsewhere on the board
GND: C1601.2, SW1601.2, SW1602.2, SW1603.2, SW1604.2, SW1605.2, SW1606.2, SW1607.2, SW1608.2, SW1609.2, SW1610.2, SW1611.2, SW1612.2, SW1613.2, SW1614.2, SW1615.2, U1601.2 (A1), U1601.3 (A2), U1601.9 (P05), U1601.10 (P06), U1601.11 (P07), U1601.12 (GND), U1601.13 (P10), U1601.21 (A0); also elsewhere on the board
I2C0_SCL: U1601.22 (SCL); also elsewhere on the board
I2C0_SDA: U1601.23 (SDA); also elsewhere on the board
MCU_~IRQ: U1601.1 (~INT); also elsewhere on the board

Notes on the sheet:
Button I/O Expander (optional)
I2C Addr: 0x20

Schematic: peripherals.kicad_sch

Parts:
C1501, C1502, C1503, C1504: 100n; C_0402_1005Metric; LCSC C1525
C1505: 22p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; LCSC C1555
D1501: 1N4148W; D_SOD-123; LCSC C81598
J1501: Vibration_Motor; Rumble_Motor_Pads
Q1501: AO3401A; SOT-23; LCSC C15127
Q1502: AO3400A; SOT-23; LCSC C20917
R1501, R1504: 10K; R_0402_1005Metric; LCSC C25744
R1502, R1503: 1K; R_0402_1005Metric; LCSC C11702
U1501: LSM6DS3TR-C; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y; LCSC C967633
U1502: PCF8563T; TSSOP-8_3x3mm_P0.65mm; LCSC C27397
Y1501: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm; LCSC C32346

Connections:
+3V3: C1501.1, C1502.2, C1503.2, D1501.1 (K), J1501.1, Q1501.2 (S), U1501.5 (VDDIO), U1501.8 (VDD), U1501.12 (CS); also elsewhere on the board
+3V3_FPGA: R1501.1; also elsewhere on the board
/Peripherals/RTC_INT: U1502.3 (~INT)
/Peripherals/RTC_OSCI: C1505.2, U1502.1 (OSCI), Y1501.1
/Peripherals/RTC_OSCO: U1502.2 (OSCO), Y1501.2
/Peripherals/Vibrate_FET_g: Q1502.1 (G), R1503.2
/Peripherals/Vibrate_N: C1503.1, D1501.2 (A), J1501.2, Q1501.3 (D), Q1502.3 (D)
/Peripherals/~Vibrate_Brake_g: Q1501.1 (G), R1502.2
GND: C1501.2, C1502.1, C1504.1, C1505.1, Q1502.2 (S), R1504.2, U1501.1 (SDO/SA0), U1501.2 (SDX), U1501.3 (SCX), U1501.6 (GND), U1501.7 (GND), U1502.4 (VSS); also elsewhere on the board
I2C0_SCL: U1501.13 (SCL), U1502.6 (SCL); also elsewhere on the board
I2C0_SDA: U1501.14 (SDA), U1502.5 (SDA); also elsewhere on the board
VSYS_ALWAYS: C1504.2, U1502.8 (VDD); also elsewhere on the board
Vibrate_En: R1503.1, R1504.1; also elsewhere on the board
~Vibrate_Brake: R1501.2, R1502.1; also elsewhere on the board

Notes on the sheet:
RTC
C = (XTAL_C - 2pF) * 2 C ~= 22 pF Honestly it's pretty much a guess
I2C Addr: 0x6A
I2C Addr: 0x51
IMU
See NXP UM10301 for oscillator info
Vibration

Schematic: fpga_io_35.kicad_sch

Parts:
C1201, C1202, C1203, C1204: 470n; C_0402_1005Metric; LCSC C47339
C1205, C1206: 4u7; C_0402_1005Metric; LCSC C23733
Q1201: AO3400A; SOT-23; LCSC C20917
R1201, R1202: 330R; R_0402_1005Metric; LCSC C25104
R1203: 10K; R_0402_1005Metric; LCSC C25744
U601: XC7A100T-CSG324; Xilinx_CSG324; LCSC C1521791

Connections:
+3V3_FPGA: C1201.1, C1202.1, C1203.1, C1204.1, C1205.1, C1206.1, U601.A7 (VCCO_35), U601.C3 (VCCO_35), U601.D6 (VCCO_35), U601.F2 (VCCO_35), U601.G5 (VCCO_35), U601.J1 (VCCO_35); also elsewhere on the board
/FPGA IO Bank 35/FPGA_IRQ: Q1201.1 (G), R1203.1, U601.J3 (IO_L22P_T3_35)
/FPGA IO Bank 35/USB_SBU_1: R1201.2, U601.F3 (IO_L13N_T2_MRCC_35)
/FPGA IO Bank 35/USB_SBU_2: R1202.2, U601.D3 (IO_L12N_T1_MRCC_35)
BTN_Down: U601.H5 (IO_L24N_T3_35); also elsewhere on the board
BTN_L: U601.E6 (IO_L5P_T0_AD13P_35); also elsewhere on the board
BTN_Left: U601.G6 (IO_L19P_T3_35); also elsewhere on the board
BTN_Right: U601.F5 (IO_0_35); also elsewhere on the board
BTN_Select: U601.J5 (IO_25_35); also elsewhere on the board
BTN_Up: U601.E5 (IO_L5N_T0_AD13N_35); also elsewhere on the board
DAC_BCLK: U601.G3 (IO_L20N_T3_35); also elsewhere on the board
DAC_DIN: U601.J4 (IO_L21P_T3_DQS_35); also elsewhere on the board
DAC_MCLK: U601.G4 (IO_L20P_T3_35); also elsewhere on the board
DAC_WCLK: U601.H4 (IO_L21N_T3_DQS_35); also elsewhere on the board
FPGA_CLK_50MHz: U601.E3 (IO_L12P_T1_MRCC_35); also elsewhere on the board
FPGA_SPI_CLK: U601.F4 (IO_L13P_T2_MRCC_35); also elsewhere on the board
FPGA_SPI_D0: U601.J2 (IO_L22N_T3_35); also elsewhere on the board
FPGA_SPI_D1: U601.H1 (IO_L17P_T2_35); also elsewhere on the board
FPGA_SPI_D2: U601.H2 (IO_L15P_T2_DQS_35); also elsewhere on the board
FPGA_SPI_D3: U601.K2 (IO_L23P_T3_35); also elsewhere on the board
FPGA_SPI_~CS: U601.K1 (IO_L23N_T3_35); also elsewhere on the board
GB_Cart_AD0: U601.B6 (IO_L2N_T0_AD12N_35); also elsewhere on the board
GB_Cart_AD1: U601.A6 (IO_L3P_T0_DQS_AD5P_35); also elsewhere on the board
GB_Cart_AD2: U601.B7 (IO_L2P_T0_AD12P_35); also elsewhere on the board
GB_Cart_AD3: U601.C4 (IO_L7P_T1_AD6P_35); also elsewhere on the board
GB_Cart_AD4: U601.D4 (IO_L11N_T1_SRCC_35); also elsewhere on the board
GB_Cart_AD5: U601.C5 (IO_L1N_T0_AD4N_35); also elsewhere on the board
GB_Cart_AD6: U601.D5 (IO_L11P_T1_SRCC_35); also elsewhere on the board
GB_Cart_AD7: U601.C6 (IO_L1P_T0_AD4P_35); also elsewhere on the board
GB_Cart_AD8: U601.D8 (IO_L4P_T0_35); also elsewhere on the board
GB_Cart_PHI: U601.B3 (IO_L10P_T1_AD15P_35); also elsewhere on the board
GB_Cart_~CS1: U601.A5 (IO_L3N_T0_DQS_AD5N_35); also elsewhere on the board
GB_Cart_~OE: U601.A3 (IO_L8N_T1_AD14N_35); also elsewhere on the board
GB_Cart_~RD: U601.B4 (IO_L7N_T1_AD6N_35); also elsewhere on the board
GB_Cart_~WR: U601.A4 (IO_L8P_T1_AD14P_35); also elsewhere on the board
GB_Dir_Cart1: U601.D7 (IO_L6N_T0_VREF_35); also elsewhere on the board
GB_Dir_Cart2: U601.C7 (IO_L4N_T0_35); also elsewhere on the board
GB_Dir_Cart3: U601.B2 (IO_L10N_T1_AD15N_35); also elsewhere on the board
GB_Dir_SC: U601.G1 (IO_L17N_T2_35); also elsewhere on the board
GB_Dir_SD: U601.F1 (IO_L18P_T2_35); also elsewhere on the board
GB_Dir_SI: U601.E1 (IO_L18N_T2_35); also elsewhere on the board
GB_Dir_SO: U601.C2 (IO_L16P_T2_35); also elsewhere on the board
GB_Link_SC: U601.G2 (IO_L15N_T2_DQS_35); also elsewhere on the board
GB_Link_SD: U601.E2 (IO_L14P_T2_SRCC_35); also elsewhere on the board
GB_Link_SI: U601.D2 (IO_L14N_T2_SRCC_35); also elsewhere on the board
GB_Link_SO: U601.C1 (IO_L16N_T2_35); also elsewhere on the board
GND: C1201.2, C1202.2, C1203.2, C1204.2, C1205.2, C1206.2, Q1201.2 (S), R1203.2; also elsewhere on the board
MCU_~IRQ: Q1201.3 (D); also elsewhere on the board
USB_SBU1: R1201.1; also elsewhere on the board
USB_SBU2: R1202.1; also elsewhere on the board
Vibrate_En: U601.B1 (IO_L9P_T1_DQS_AD7P_35); also elsewhere on the board
~Vibrate_Brake: U601.A1 (IO_L9N_T1_DQS_AD7N_35); also elsewhere on the board

Notes on the sheet:
Single-ended clock must go to P pin
IRQ

Schematic: gb_link.kicad_sch

Parts:
C1, C3, C4: 100p; C_0402_1005Metric; LCSC C1546
C2004, C2005, C2006, C2007, C2008, C2009, C2010, C2011: 100n; C_0402_1005Metric; LCSC C1525
D2001: H5VU25U; Diodes_UDFN-10_1.0x2.5mm_P0.5mm; LCSC C7420374
J2001: Link_Port; GameBoy_LinkPort_AGB_Horizontal
R2, R3, R4, R5: 330R; R_0402_1005Metric; LCSC C25104
R2005, R2006, R2007: 47K; R_0402_1005Metric; LCSC C25792
R2008: 30K; R_0402_1005Metric; LCSC C25776
U2001, U2002, U2003, U2004: 74LVC1T45; SOT-363_SC-70-6; LCSC C168855

Connections:
+3V3_FPGA: C2005.2, C2007.2, C2009.2, C2011.2, U2001.1 (VCCA), U2002.1 (VCCA), U2003.1 (VCCA), U2004.1 (VCCA); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SC: R2008.2, U2004.4 (B); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SC_a: D2001.5 (K4), D2001.6 (K4), J2001.5 (SC); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SD: R2006.2, U2002.4 (B); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SD_a: D2001.4 (K3), D2001.7 (K3), J2001.4 (SD); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SI: R2007.2, U2003.4 (B); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SI_a: D2001.2 (K2), D2001.9 (K2), J2001.3 (SI); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SO: R2005.2, U2001.4 (B); also elsewhere on the board
/Game Boy Interfaces/Game Boy Link/Link_SO_a: D2001.1 (K1), D2001.10 (K1), J2001.2 (SO); also elsewhere on the board
GB_Dir_SC: U2004.5 (DIR); also elsewhere on the board
GB_Dir_SD: U2002.5 (DIR); also elsewhere on the board
GB_Dir_SI: U2003.5 (DIR); also elsewhere on the board
GB_Dir_SO: U2001.5 (DIR); also elsewhere on the board
GB_Link_SC: U2004.3 (A); also elsewhere on the board
GB_Link_SD: U2002.3 (A); also elsewhere on the board
GB_Link_SI: U2003.3 (A); also elsewhere on the board
GB_Link_SO: U2001.3 (A); also elsewhere on the board
GND: C2004.1, C2005.1, C2006.1, C2007.1, C2008.1, C2009.1, C2010.1, C2011.1, D2001.3 (A), D2001.8 (A), J2001.6 (GND), J2001.SH, U2001.2 (GND), U2002.2 (GND), U2003.2 (GND), U2004.2 (GND); also elsewhere on the board
VGB: C2004.2, C2006.2, C2008.2, C2010.2, J2001.1 (VDD), R2005.1, R2006.1, R2007.1, R2008.1, U2001.6 (VCCB), U2002.6 (VCCB), U2003.6 (VCCB), U2004.6 (VCCB); also elsewhere on the board

Notes on the sheet:
For SC: 100K and 47K in parallel = ~32K
